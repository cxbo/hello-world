# Keil uVision project STM32F030C8T6.uvprojx, settings and files
target STM32F030C8T6 (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: STM32F030C8T6 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\Library\CMSIS;..\Library\STM32F0xx_StdPeriph_Driver\inc;..\Library\STM32F0xx_StdPeriph_Driver\src;..\User;..\Library\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./: startup_stm32f030.s
    ../User/: system_stm32f0xx.c stm32f0xx_it.c main.c
  group STM32F0xx_StdPeriph_Driver
    ../Library/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_usart.c
